* smart_vco schematic
.end
