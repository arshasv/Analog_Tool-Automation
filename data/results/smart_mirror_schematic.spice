* smart_mirror schematic
.end
